# Keil uVision project DollyBot.uvprojx, settings and files
target DollyBot_F405 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0xC0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: DollyBot +hex
  c flags: Optim=2 v6Lang=3 wLevel=3
  c define: STM32F405xx
  c misc: -I../src -I../board -I../../shared -I../vendor/st -I../vendor/cmsis -std=c11 -mfpu=fpv4-sp-d16 -mfloat-abi=hard
  c include: ..\src;..\board;..\..\shared;..\vendor\st;..\vendor\cmsis
  scatter file: .\DollyBot.sct
  link misc: --map --info=sizes
  group Motion and protocol
    ../src/: motion.c wire.c task_store.c vehicle.c
  group STM32F405 board
    ../board/: main.c board.c flash.c
    ../vendor/st/: startup_stm32f405xx.s
